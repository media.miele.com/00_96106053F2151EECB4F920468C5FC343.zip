Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-05-12T09:13:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 12 09:13:21 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\3de55038-7a61-458d-b3e8-03f53316f2ef\8f0ada96-417c-4150-b51b-d64a10816aa4\ifc * Database version: 5507 * Database creation date: Thu May 12 09:13:20 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 12 09:13:21 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 12 09:13:21 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11776630_S_APCL090_IG:59590090_S_11776630_APCL090_IG, (2)
In: Default
Type - Material: z_Miele_Connection_Water_OUT, z_Miele_Design_CLST, Thermoplastic Resin
Type - Pset_BuildingElementProxyCommon - Reference: 59590090_S_11776630_APCL090_IG
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 59590090_S_11776630_APCL090_IG
Pset_BuildingElementProxyCommon - sets with these values: 2
